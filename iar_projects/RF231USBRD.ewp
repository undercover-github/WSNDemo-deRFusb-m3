# IAR project RF231USBRD.ewp, settings and files
configuration All_Rf231UsbRd_At91sam3s4c_Rf231 (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  ICCARM.CCDefines: BOARD_RF231USBRD; AT91SAM3S4C; HAL_64MHz; AT86RF231; STACK_TYPE_ALL; NO_SECURITY_MODE
  ICCARM.CCDiagSuppress: Pa050,Pe188
  ICCARM.PreInclude: MakerulesBc_All_At91sam3s4c_Rf231_Iar.h
  ICCARM.CCIncludePath2: ..; ../include; ../../../BitCloud/Components/BSP/RF231USBRD/include; ../../../BitCloud/Components/HAL/drivers/include; ../../../BitCloud/Components/HAL/drivers/USBClasses/common/include; ../../../BitCloud/Components/HAL/drivers/USBClasses/VCP/include; ../../../BitCloud/lib; ../../../BitCloud/Components/HAL/include; ../../../BitCloud/Components/BSP; ../../../BitCloud/Components/BSP/include; ../../../BitCloud/Components/NWK/include; ../../../BitCloud/Components/NWK/include/private; ../../../BitCloud/Components/ZDO/include; ../../../BitCloud/Components/ZDO/include/private; ../../../BitCloud/Components/APS/include; ../../../BitCloud/Components/APS/include/private; ../../../BitCloud/Components/SystemEnvironment/include; ../../../BitCloud/Components/ConfigServer/include; ../../../BitCloud/Components/ConfigServer/include/private; ../../../BitCloud/Components/PersistDataServer/include; ../../../BitCloud/Components/PersistDataServer/include/private; ../../../BitCloud/Components/Security/TrustCentre/include; ../../../BitCloud/Components/Security/ServiceProvider/include; ../../../BitCloud/Components/HAL/cortexm3/at91sam3s4c/common/include; ../../../BitCloud/Components/HAL/cortexm3/at91sam3s4c/Rf231UsbRd/include; ../../../BitCloud/Components/MAC_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_ENV/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWI/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/RF231_RF212/PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/RF231_RF212/MAC_HWD/include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: AT91SAM3S4C
  OBJCOPY.OOCOutputFile: WSNDemo.srec
  ILINK.IlinkOutputFile: WSNDemo.out
  ILINK.IlinkIcfFile: ../linkerScr/at91SAM3S4C_FLASH.icf
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libHAL_Rf231UsbRd_At91sam3s4c_64Mhz_Iar.a; ../../../BitCloud/lib/libBc_All_At91sam3s4c_Rf231_Iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration All_Sec_Rf231UsbRd_At91sam3s4c_Rf231 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_RF231USBRD; AT91SAM3S4C; HAL_64MHz; AT86RF231; STACK_TYPE_ALL; STANDARD_SECURITY_MODE
  ICCARM.PreInclude: MakerulesBc_All_Sec_At91sam3s4c_Rf231_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libHAL_Rf231UsbRd_At91sam3s4c_64Mhz_Iar.a; ../../../BitCloud/lib/libBc_All_Sec_At91sam3s4c_Rf231_Iar.a
configuration All_StdlinkSec_Rf231UsbRd_At91sam3s4c_Rf231 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_RF231USBRD; AT91SAM3S4C; HAL_64MHz; AT86RF231; STACK_TYPE_ALL; STDLINK_SECURITY_MODE
  ICCARM.PreInclude: MakerulesBc_All_StdlinkSec_At91sam3s4c_Rf231_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libHAL_Rf231UsbRd_At91sam3s4c_64Mhz_Iar.a; ../../../BitCloud/lib/libBc_All_StdlinkSec_At91sam3s4c_Rf231_Iar.a
  group src
    ../src/: WSNSensorManager.c WSNEndDevice.c WSNCoord.c WSNVisualizer.c WSNMessageSender.c WSNCommandHandler.c WSNRouter.c WSNDemoApp.c WSNUARTManager.c
  group include
    ../include/: WSNZclManager.h WSNVisualizer.h WSNUARTManager.h WSNMessageSender.h WSNCoord.h WSNDemoApp.h WSNEndDevice.h WSNRouter.h WSNCommandHandler.h WSNSensorManager.h WSNCommand.h serialInterface.h
  group Components/PersistDataServer/src
    ../../../BitCloud/Components/PersistDataServer/src/: pdsMem.c pdsWriteData.c pdsDataServer.c pdsInit.c pdsTimer.c pdsEvents.c pdsMemAccess.c pdsCrcService.c
  group Components/PersistDataServer/include
    ../../../BitCloud/Components/PersistDataServer/include/: pdsDataServer.h
  group Components/PersistDataServer/include/private
    ../../../BitCloud/Components/PersistDataServer/include/private/: pdsDbg.h pdsMemAccess.h pdsCrcService.h pdsTimer.h pdsMem.h pdsWriteData.h pdsMemAbstract.h
  group Components/BSP/src
    ../../../BitCloud/Components/BSP/RF231USBRD/src/: leds.c bspTaskManager.c fakeBSP.c
  group Components/USBClasses/VCP/src
    ../../../BitCloud/Components/HAL/drivers/USBClasses/VCP/src/: vcpVirtualUsart.c vcpCdcProtocol.c
  group Components/USBClasses/common/src
    ../../../BitCloud/Components/HAL/drivers/USBClasses/common/src/: usbSetupProcess.c usbDescriptors.c usbEnumeration.c
  group Components/ConfigServer/src
    ../../../BitCloud/Components/ConfigServer/src/: csPersistentMem.c csMem.c configServer.c
  group Components/ConfigServer/include
    ../../../BitCloud/Components/ConfigServer/include/: csDefaulfts.h configServer.h
  group Components/ConfigServer/include/private
    ../../../BitCloud/Components/ConfigServer/include/private/: csParamTable.h csBuffers.h csDbg.h csSIB.h
  group configuration
    ../: configuration.h
